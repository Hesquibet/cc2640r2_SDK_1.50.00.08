# IAR project cc2640r2lp_app.ewp, settings and files
configuration uNPI_CM_FlashOnly_MultiMode (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; xFEATURE_ADVERTISER; xFEATURE_BROADCASTER; FEATURE_CM; FEATURE_MONITOR; xFEATURE_OBSERVER; xFEATURE_SCANNER; FEATURE_STATIC_ADDR; HEAPMGR_SIZE=0; NPI_USE_UART; xPOWER_SAVING; RF_MULTIMODE; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $XDCROOT$\packages; $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\boards; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $EXAMPLE_BLE_ROOT$\src\app\board_cc2640r2lp; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\npi\src\unified; $SRC_BLE_DIR$\npi\src\unified\inc; $SRC_BLE_DIR$\osal\src\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\rf_patches; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\app_ble.cfg
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: ble_connection_monitor_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app.icf
  ILINK.IlinkExtraOptions: -f ..\config\configPkg\linker.cmd
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_multiMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration CM_FlashOnly_MultiMode (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_DISPLAY_USE_UART=1; BOARD_DISPLAY_USE_UART_ANSI=1; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; xDisplay_DISABLE_ALL; xFEATURE_ADVERTISER; xFEATURE_BROADCASTER; FEATURE_CM; FEATURE_MONITOR; xFEATURE_OBSERVER; xFEATURE_SCANNER; FEATURE_STATIC_ADDR; HEAPMGR_SIZE=0; xNPI_USE_UART; xPOWER_SAVING; RF_MULTIMODE; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $XDCROOT$\packages; $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\boards; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $EXAMPLE_BLE_ROOT$\src\app\board_cc2640r2lp; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\npi\src\unified; $SRC_BLE_DIR$\npi\src\unified\inc; $SRC_BLE_DIR$\osal\src\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  group Application
    $EXAMPLE_BLE_ROOT$/src/app/: micro_ble_cm.c micro_ble_cm.h micro_cm_app.c micro_cm_app.h micro_cm_demo.c micro_cm_demo.h
  group HAL/Common
    $SRC_BLE_DIR$/hal/src/common/: hal_assert.c
  group HAL/Include
    $SRC_BLE_DIR$/hal/src/inc/: hal_assert.h
  group NPI/Transport
    $SRC_BLE_DIR$/npi/src/unified/: npi_tl.c
    $SRC_BLE_DIR$/npi/src/unified/inc/: npi_tl.h
  group NPI/Transport/UART
    $SRC_BLE_DIR$/npi/src/unified/: npi_tl_uart.c
    $SRC_BLE_DIR$/npi/src/unified/inc/: npi_tl_uart.h
  group NPI/U_NPI
    $$SRC_BLE_DIR$/npi/src/unified/inc/: npi_data.h
    $SRC_BLE_DIR$/npi/src/unified/: npi_task.c npi_util.c
    $SRC_BLE_DIR$/npi/src/unified/inc/: npi_task.h npi_util.h
  group Stack
    $SRC_BLE_DIR$/microstack/: port.c uble.c ugap.c ull.c urfi.c
    $SRC_BLE_DIR$/inc/: port.h uble.h ugap.h ull.h urfi.h
  group Startup
    $SRC_BLE_DIR$/target/: board.c
    $EXAMPLE_BLE_ROOT$/src/: ccfg_app_ble.c
    $EXAMPLE_BLE_ROOT$/src/app/: main.c
    $SRC_BLE_DIR$/boards/: urfc.c urfc.h
  group Tools
    ../../: app_ble.cfg
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_app.icf
  group Util
    $SRC_BLE_DIR$/common/cc26xx/: util.c util.h
