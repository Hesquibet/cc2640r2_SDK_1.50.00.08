# IAR project cc2640r2lp_app.ewp, settings and files
configuration FlashROM_StackLibrary (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=4; MAX_PDU_SIZE=255; NPI_SPI_CONFIG=Board_SPI0; xNPI_USE_SPI; NPI_USE_UART; xPOWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $EXAMPLE_BLE_ROOT$; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.bin
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" --cfgArgs NO_ROM=0 -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\app_ble.cfg
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\$TARGET_BNAME$.bin
  ILINK.IlinkOutputFile: ble_host_test_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_and_stack.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: ..\config\ble_r2.symbols; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_singleMode_cc26x0r2.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\grlib.arm3; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\mw\lcd\lib\lcd.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_StackLibrary_RCOSC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=4; MAX_PDU_SIZE=255; NPI_SPI_CONFIG=Board_SPI0; xNPI_USE_SPI; NPI_USE_UART; xPOWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; USE_ICALL; USE_RCOSC; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx_r2\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\rcosc; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\roles; $SRC_BLE_DIR$\profiles\roles\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $EXAMPLE_BLE_ROOT$; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
configuration FlashROM_StackLibrary-CacheAsRAM (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: CACHE_AS_RAM; CC2640R2_LAUNCHXL; CC26XX; CC26XX_R2; DeviceFamily_CC26X0R2; Display_DISABLE_ALL; ICALL_EVENTS; ICALL_JT; ICALL_LITE; ICALL_MAX_NUM_ENTITIES=6; ICALL_MAX_NUM_TASKS=3; ICALL_STACK0_ADDR; MAX_NUM_BLE_CONNS=8; MAX_PDU_SIZE=255; NPI_SPI_CONFIG=Board_SPI0; xNPI_USE_SPI; NPI_USE_UART; xPOWER_SAVING; RF_SINGLEMODE; STACK_LIBRARY; USE_ICALL; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ILINK.IlinkConfigDefines: CC2650=2; FLASH_ROM_BUILD=2; CACHE_AS_RAM=1
  group Application
    $EXAMPLE_BLE_ROOT$/src/app/: host_test_app.c host_test_app.h
    $SRC_BLE_DIR$/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    $SRC_BLE_DIR$/common/cc26xx/: util.c util.h
  group Drivers/ECC
    $SRC_BLE_DIR$/common/cc26xx/ecc/: ECCROMCC26XX.c ECCROMCC26XX.h
  group Drivers/TRNG
    $SRC_BLE_DIR$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SRC_BLE_DIR$/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SRC_BLE_DIR$/icall/src/inc/: icall.h icall_user_config.h
    $SRC_BLE_DIR$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_DIR$/icall/app/: ble_user_config.c icall_api_lite.c icall_hci_tl.c
    $SRC_BLE_DIR$/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group NPI
    $SRC_BLE_DIR$/npi/src/inc/: npi_ble.h npi_frame.h npi_rxbuf.h npi_task.h
    $SRC_BLE_DIR$/npi/src/: npi_frame_hci.c npi_rxbuf.c npi_task.c
  group NPI/Transport
    $SRC_BLE_DIR$/npi/src/inc/: npi_config.h npi_tl.h
    $SRC_BLE_DIR$/npi/src/: npi_tl.c
  group NPI/Transport/SPI
    $SRC_BLE_DIR$/npi/src/: npi_tl_spi.c
    $SRC_BLE_DIR$/npi/src/inc/: npi_tl_spi.h
  group NPI/Transport/UART
    $SRC_BLE_DIR$/npi/src/: npi_tl_uart.c
    $SRC_BLE_DIR$/npi/src/inc/: npi_tl_uart.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc2640r2lp_stack_FlashROM_Library.a
  group Startup
    $SRC_BLE_DIR$/target/: board.c
    $EXAMPLE_BLE_ROOT$/src/: ccfg_app_ble.c
    $SRC_BLE_DIR$/common/cc26xx/rcosc/: ccfg_app_ble_rcosc.c
    $EXAMPLE_BLE_ROOT$/src/app/: main.c
  group Tools
    ../../: app_ble.cfg
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_app_and_stack.icf
