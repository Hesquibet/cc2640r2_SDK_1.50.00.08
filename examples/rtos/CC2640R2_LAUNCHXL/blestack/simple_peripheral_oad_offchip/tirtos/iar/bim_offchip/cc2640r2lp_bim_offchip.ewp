# IAR project cc2640r2lp_bim_offchip.ewp, settings and files
configuration FlashOnly (ARM, debug)
  General.OGChipSelectEditMenu: CC2640R2F TexasInstruments CC2640R2F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: BOOT_LOADER; xCREATE_FACT_IMG_INT_TO_EXT_FLSH; xJTAG_DEBUG; xNO_COPY; ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages; $SRC_BLE_DIR$\common\cc26xx\board_support_pkg\CC2640R2_LAUNCHXL\; $XDCROOT$\packages; $EXAMPLE_BLE_ROOT$\cc26xx\board; $EXAMPLE_BLE_ROOT$\cc26xx\; $EXAMPLE_BLE_ROOT$\src; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\crc; $SRC_BLE_DIR$\common\cc26xx\bim; $SRC_BLE_DIR$\common\cc26xx\flash_interface; $SRC_BLE_DIR$\profiles\oad\cc26xx; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target; $SRC_BLE_DIR$\osal\src\inc; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sp_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.bin
  postbuild: $TOOLS_BLE_DIR$\output_converter\output_converter.exe $EXE_DIR$\sp_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.bin -a 0x0001F000
  ILINK.IlinkOutputFile: sp_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2650=2
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_bim_r2.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc26x0r2\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    $EXAMPLE_BLE_ROOT$/src/bim_offchip/: bim_main.c ccfg_app_ble.c
    $SRC_BLE_DIR$/common/cc26xx/bim/: bim_util.c bim_util.h
    $SRC_BLE_DIR$/common/cc26xx/crc/: crc32.c crc32.h
    $SRC_BLE_DIR$/common/cc26xx/flash_interface/internal/: flash_interface_internal.c
    $SRC_BLE_DIR$/profiles/oad/cc26xx/: oad_image_header.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/devices/cc26x0r2/startup_files/: startup_iar.c
  group Board
    $SRC_BLE_DIR$/common/cc26xx/board_support_pkg/CC2640R2_LAUNCHXL/: bsp.h
  group Ext Flash
    $SRC_BLE_DIR$/common/cc26xx/board_support_pkg/CC2640R2_LAUNCHXL/: ext_flash.c ext_flash.h
  group SPI
    $SRC_BLE_DIR$/common/cc26xx/board_support_pkg/CC2640R2_LAUNCHXL/: bsp_spi.c bsp_spi.h
  group TOOLS
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_bim_r2.icf
